# Keil uVision project stm32H7_bl_V1.0.uvprojx, settings and files
target stm32H7_bl_V1.0 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H743VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00080000) IROM2(0x08100000,0x00080000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: stm32H7_bl_V1.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: STM32H743xx,USE_HAL_DRIVER
  c include: .\Library\STM32H7xx_HAL_Driver\Inc;.\Library\CMSIS\Include;.\Library\CMSIS\Device\ST\STM32H7xx\Include;.\Library\STM32H7xx_HAL_Driver\Inc\Legacy\;.\driver;.\middle;.\app\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7fff
  memory RVCT5: ROM 0x8100000 size 0x80000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group app
    ./app/src/: main.c App_Link.c App_Usart.c App_TurnToApp.c
  group driver
    ./driver/: Driver_Sleep.c
  group middle
    ./middle/: Driver_Uart.c
    ./driver/: embeddedFlashMemory.c ota.c
  group library
    ./startup/: system_stm32h7xx.c
    ./Library/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_gpio.c stm32h7xx_hal.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c
  group startup
    ./startup/: startup_stm32h743xx.s
software components: CMSIS:CORE 5.4.0

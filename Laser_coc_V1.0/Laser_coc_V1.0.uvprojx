# Keil uVision project Laser_coc_V1.0.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H743VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00080000) IROM2(0x08100000,0x00080000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Laser_coc_V1.0
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32H743xx,MQTT_DO_NOT_USE_CUSTOM_CONFIG,STM32H7
  c include: .\Source\kernel\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;.\Source\startup\include;.\Source\bsp\BspH7\Inc;.\Source\bsp\CMSIS\include;.\Source\bsp\CMSIS\Core\Include;.\Source\kernel\FreeRTOS\include;.\Source\app\inc;.\Source\component\FreeRTOS-Plus-TCP\include;.\Source\component\FreeRTOS-Plus-TCP\portable\Compiler;.\Source\component\coreMQTT\source\include;.\Source\component\coreMQTT\source\interface;.\Source\component\FreeRTOS-IoT\sockets_wrapper\freertos_plus_tcp;.\Source\component\FreeRTOS-IoT\using_plaintext;.\Source\component\FreeRTOS-IoT\Utilities\backoff_algorithm;.\Source\component\FreeRTOS-IoT\Utilities\logging;.\Source\component\FreeRTOS-IoT;.\Source\component\NetworkInterface\include;.\Source\middle\Command\inc;.\Source\middle\PID\inc;.\Source\bsp\Driver\inc;.\Source\middle\OTA\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x40000
  memory RVCT5: ROM 0x8100000 size 0x80000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group startup
    ./Source/startup/: startup_stm32h743xx.s stm32h7xx_hal_msp.c stm32h7xx_it.c system_stm32h7xx.c
  group app
    ./Source/app/inc/: app_cfg.h
    ./Source/app/: main.c MessagePass.c PlaintextMQTT.c EthernetTCPIP.c ControlParam.c FunctionSet.c ComHandle.c
  group bsp\BspH7
    ./Source/bsp/BspH7/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c
  group bsp\CMSIS
    ./Source/bsp/CMSIS/: clib_arm.c cmsis_os2.c os_systick.c
  group component\coreMQTT
    ./Source/component/coreMQTT/source/: core_mqtt.c core_mqtt_serializer.c core_mqtt_state.c
  group component\FreeRTOS-IoT
    ./Source/component/FreeRTOS-IoT/sockets_wrapper/freertos_plus_tcp/: sockets_wrapper.c
    ./Source/component/FreeRTOS-IoT/using_plaintext/: using_plaintext.c
    ./Source/component/FreeRTOS-IoT/Utilities/backoff_algorithm/: backoff_algorithm.c
  group component\FreeRTOS-Plus-TCP
    ./Source/component/FreeRTOS-Plus-TCP/: FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c FreeRTOS_BitConfig.c FreeRTOS_DHCPv6.c FreeRTOS_DNS_Cache.c FreeRTOS_DNS_Callback.c FreeRTOS_DNS_Networking.c FreeRTOS_DNS_Parser.c FreeRTOS_ICMP.c FreeRTOS_IP_Timers.c FreeRTOS_IP_Utils.c FreeRTOS_IPv4.c FreeRTOS_IPv4_Sockets.c FreeRTOS_IPv4_Utils.c FreeRTOS_IPv6.c FreeRTOS_IPv6_Sockets.c FreeRTOS_IPv6_Utils.c FreeRTOS_ND.c FreeRTOS_RA.c FreeRTOS_Routing.c FreeRTOS_TCP_IP_IPv4.c FreeRTOS_TCP_IP_IPv6.c FreeRTOS_TCP_Reception.c FreeRTOS_TCP_State_Handling.c FreeRTOS_TCP_State_Handling_IPv4.c FreeRTOS_TCP_State_Handling_IPv6.c FreeRTOS_TCP_Transmission.c FreeRTOS_TCP_Transmission_IPv4.c FreeRTOS_TCP_Transmission_IPv6.c FreeRTOS_TCP_Utils.c FreeRTOS_TCP_Utils_IPv4.c FreeRTOS_TCP_Utils_IPv6.c FreeRTOS_Tiny_TCP.c FreeRTOS_UDP_IPv4.c FreeRTOS_UDP_IPv6.c
    ./Source/component/FreeRTOS-Plus-TCP/portable/BufferManagement/: BufferAllocation_2.c
  group component\NetworkInterface
    ./Source/component/NetworkInterface/include/: FreeRTOSIPConfig.h
    ./Source/component/NetworkInterface/: NetworkInterface.c phyHandling.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c
  group kernel\FreeRTOS
    ./Source/kernel/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Source/kernel/FreeRTOS/portable/MemMang/: heap_4.c
    ./Source/kernel/FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
  group middle\Command
    ./Source/middle/Command/src/: CommandFrame.c CommandFrame_1.c
  group bsp\Driver
    ./Source/bsp/Driver/src/: EmbeddedFlashMemory.c Driver_I2C.c ADS1115.c SGM5348.c AT24CM01.c TCA9535.c TCA9548.c TMP112.c
    ../../../SicBurnIn/Embedded/core_mqtt_V1.0/Source/bsp/Driver/src/: Driver_Uart.c
  group middle\PID
    ./Source/middle/PID/src/: PID.c
  group middle\OTA
    ./Source/middle/OTA/src/: ota.c
software components: Compiler:I/O:STDERR 1.2.0
